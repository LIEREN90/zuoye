# Repository LIEREN90/zuoye

## KiCad design zuoye1/zuoye1.kicad_pcb

Parts:
C8, C9, C10, C11, C12, C13: 100n; C_0603_1608Metric
C14, C15: 18p; C_0603_1608Metric
J4, J5: Conn_01x19; PinHeader_1x19_P2.54mm_Vertical
J6: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
R4, R5: 10k; R_0603_1608Metric
SW1: SW_Push; SW_Push_1P1T_NO_6x6mm_H9.5mm
U4: STM32F103C8T6; LQFP-48_7x7mm_P0.5mm
Y1: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C8.1, C9.1, C10.1, C11.1, C12.1, J5.17, J5.18, J6.1, R4.1, U4.1 (VBAT), U4.9 (VDDA), U4.24 (VDD), U4.36 (VDD), U4.48 (VDD); also elsewhere on the board
/KEY&LED/BLUE: J5.7, U4.39 (PB3); also elsewhere on the board
/KEY&LED/GREEN: J5.6, U4.38 (PA15); also elsewhere on the board
/STM32_MiniumSystem/BOOT0: J6.2, R5.1, U4.44 (BOOT0)
/STM32_MiniumSystem/NRST: C13.1, R4.2, SW1.2, U4.7 (NRST)
/STM32_MiniumSystem/OSC_IN: C14.2, U4.5 (PD0), Y1.1
/STM32_MiniumSystem/OSC_OUT: C15.2, U4.6 (PD1), Y1.3
/STM32_MiniumSystem/PA0: J4.1, U4.10 (PA0); also elsewhere on the board
/STM32_MiniumSystem/PA1: J4.2, U4.11 (PA1)
/STM32_MiniumSystem/PA2: J4.3, U4.12 (PA2)
/STM32_MiniumSystem/PA3: J4.4, U4.13 (PA3)
/STM32_MiniumSystem/PA4: J4.5, U4.14 (PA4); also elsewhere on the board
/STM32_MiniumSystem/PA5: J4.6, U4.15 (PA5); also elsewhere on the board
/STM32_MiniumSystem/PA6: J4.7, U4.16 (PA6)
/STM32_MiniumSystem/PA7: J4.8, U4.17 (PA7); also elsewhere on the board
/STM32_MiniumSystem/PA8: J5.1, U4.29 (PA8)
/STM32_MiniumSystem/PA9: J5.2, U4.30 (PA9); also elsewhere on the board
/STM32_MiniumSystem/PA10: J5.3, U4.31 (PA10); also elsewhere on the board
/STM32_MiniumSystem/PA11: J5.4, U4.32 (PA11); also elsewhere on the board
/STM32_MiniumSystem/PA12: J5.5, U4.33 (PA12); also elsewhere on the board
/STM32_MiniumSystem/PA13: U4.34 (PA13); also elsewhere on the board
/STM32_MiniumSystem/PA14: U4.37 (PA14); also elsewhere on the board
/STM32_MiniumSystem/PB0: J4.9, U4.18 (PB0)
/STM32_MiniumSystem/PB1: J4.10, U4.19 (PB1)
/STM32_MiniumSystem/PB2: J4.11, U4.20 (PB2)
/STM32_MiniumSystem/PB4: J5.8, U4.40 (PB4); also elsewhere on the board
/STM32_MiniumSystem/PB5: J5.9, U4.41 (PB5)
/STM32_MiniumSystem/PB6: J5.10, U4.42 (PB6)
/STM32_MiniumSystem/PB7: J5.11, U4.43 (PB7)
/STM32_MiniumSystem/PB8: J5.12, U4.45 (PB8); also elsewhere on the board
/STM32_MiniumSystem/PB9: J5.13, U4.46 (PB9); also elsewhere on the board
/STM32_MiniumSystem/PB10: J4.12, U4.21 (PB10)
/STM32_MiniumSystem/PB11: J4.13, U4.22 (PB11)
/STM32_MiniumSystem/PB12: J4.14, U4.25 (PB12)
/STM32_MiniumSystem/PB13: J4.15, U4.26 (PB13)
/STM32_MiniumSystem/PB14: J4.16, U4.27 (PB14)
/STM32_MiniumSystem/PB15: J4.17, U4.28 (PB15)
/STM32_MiniumSystem/PC13: J5.14, U4.2 (PC13)
/STM32_MiniumSystem/PC14: J5.15, U4.3 (PC14)
/STM32_MiniumSystem/PC15: J5.16, U4.4 (PC15)
GND: C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.1, J4.19, J5.19, R5.2, SW1.1, U4.8 (VSSA), U4.23 (VSS), U4.35 (VSS), U4.47 (VSS), Y1.2, Y1.4; also elsewhere on the board
VBUS: J4.18; also elsewhere on the board

Notes on the sheet:
PORT
Fliter
MCU
XTAL

Parts:
C19: 100n; C_0603_1608Metric
J7: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
U5: AD8400ARZ50; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C19.1, U5.6 (VDD); also elsewhere on the board
/STM32_MiniumSystem/PA0: J7.2, U5.7 (W1); also elsewhere on the board
/STM32_MiniumSystem/PA4: U5.3 (~CS); also elsewhere on the board
/STM32_MiniumSystem/PA5: U5.5 (CLK); also elsewhere on the board
/STM32_MiniumSystem/PA7: U5.4 (SDI); also elsewhere on the board
GND: C19.2, U5.2 (GND); also elsewhere on the board
unnamed: J7.1, U5.8 (A1)
unnamed: J7.3, U5.1 (B1)

Parts:
C1, C3: 10u; C_0603_1608Metric
C2, C4, C5, C6, C7: 100n; C_0603_1608Metric
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
J2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J3: Conn_01x02; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
Q1: Q_NMOS_SGD; TSOT-23
R1: 1k; R_0603_1608Metric
R2: 10k; R_0603_1608Metric
R3: 120; R_0603_1608Metric
U1: HX9193; SOT-23-5_HandSoldering
U2: TJA1051T-3; SOIC-8_3.9x4.9mm_P1.27mm
U3: CH340E; MSOP-10_3x3mm_P0.5mm

Connections:
+3V3: C3.1, C4.1, C6.1, C7.1, Q1.1 (S), U1.5 (VOUT), U2.5 (VIO), U3.7 (VCC), U3.10 (V3); also elsewhere on the board
/PORT&POWER/3V3_Debug: J2.1, Q1.3 (D)
/PORT&POWER/CAN+: J3.1, R3.1, U2.7 (CANH)
/PORT&POWER/CAN-: J3.2, R3.2, U2.6 (CANL)
/PORT&POWER/D+: J1.A6 (D+), J1.B6 (D+), U3.1 (UD+)
/PORT&POWER/D-: J1.A7 (D-), J1.B7 (D-), U3.2 (UD-)
/STM32_MiniumSystem/PA9: U3.9 (RXD); also elsewhere on the board
/STM32_MiniumSystem/PA10: U3.8 (TXD); also elsewhere on the board
/STM32_MiniumSystem/PA11: U2.4 (RXD); also elsewhere on the board
/STM32_MiniumSystem/PA12: U2.1 (TXD); also elsewhere on the board
/STM32_MiniumSystem/PA13: J2.2; also elsewhere on the board
/STM32_MiniumSystem/PA14: J2.3; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.4, R2.1, U1.2 (GND), U2.2 (GND), U2.8 (S), U3.3 (GND); also elsewhere on the board
unnamed: Q1.2 (G), R1.2, R2.2
VBUS: C1.1, C2.1, C5.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R1.1, U1.1 (VIN), U1.3 (EN), U2.3 (VCC); also elsewhere on the board

Notes on the sheet:
DEBUGGER
PWR_FLAG
UART
POWER_SUPPLY
CAN
USB_PORT

Parts:
C16, C17, C18: 100n; C_0603_1608Metric
D1, D2, D3: LED; LED_0603_1608Metric
R6, R7, R8, R9, R10, R11: 1K; R_0603_1608Metric
SW2, SW3, SW4: SW_Push; SW_Push_1P1T_NO_6x6mm_H9.5mm

Connections:
+3V3: R6.1, R7.1, R8.1, R9.1, R10.1, R11.1; also elsewhere on the board
/KEY&LED/BLUE: D3.1 (K); also elsewhere on the board
/KEY&LED/GREEN: D2.1 (K); also elsewhere on the board
/STM32_MiniumSystem/PB4: C16.1, R6.2, SW2.2; also elsewhere on the board
/STM32_MiniumSystem/PB8: C17.1, R7.2, SW3.2; also elsewhere on the board
/STM32_MiniumSystem/PB9: C18.1, R8.2, SW4.2; also elsewhere on the board
GND: C16.2, C17.2, C18.2, D1.1 (K), SW2.1, SW3.1, SW4.1; also elsewhere on the board
unnamed: D1.2 (A), R9.2
unnamed: D2.2 (A), R10.2
unnamed: D3.2 (A), R11.2

Notes on the sheet:
KEY
LED

Board: 2 copper layers, 50 parts (0 on the bottom side), 53 nets.

## Commit log

2022-10-03 Add something
2022-10-03 Add 456.txt
2022-10-08 Add zuoye1
